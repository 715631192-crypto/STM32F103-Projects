# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Library;..\Start;..\User;..\Styem;..\Hardware;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c main.h
  group Hardware
    ../Hardware/beep/: h_beep.c h_beep.h
    ../Hardware/delay/: h_delay.c h_delay.h
    ../Hardware/flash/: h_flash.c h_flash.h
    ../Hardware/key/: h_key.c h_key.h
    ../Hardware/led/: h_led.c h_led.h
    ../Hardware/rcc/: h_rcc.c h_rcc.h
    ../Hardware/servo/: h_servo.c h_servo.h
    ../Hardware/timer/: h_timer.c h_timer.h
    ../Hardware/usart/: h_usart.c h_usart.h
    ../Hardware/ps2/: h_ps2.c h_ps2.h
  group Application
    ../Application/app_gpio/: app_gpio.c app_gpio.h
    ../Application/app_servo/: app_servo.c app_servo.h
    ../Application/app_usart/: app_usart.c app_usart.h
    ../Application/app_ps2/: app_ps2.c app_ps2.h

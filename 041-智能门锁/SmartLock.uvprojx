# Keil uVision project SmartLock.uvprojx, settings and files
target STM32F103C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: SmartLock +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\firmware\stm32\include;.\firmware\app\include;.\firmware\FreeRTOS\include;.\firmware\FreeRTOS\portable\RVDS\ARM_CM3;.\firmware\USER;.\firmware\SYSTEM;.\firmware\HARDWARE;.\firmware\MIDDLEWARE;D:\Keil_v5\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include;D:\Keil_v5\Packs\Keil\STM32F1xx_DFP\2.3.0\Device\Include;D:\Keil_v5\Packs\Keil\STM32F1xx_DFP\2.3.0\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\STM32F103C8.sct
  group Startup
    ./: startup_stm32f103xb.s
  group APP_Core
    firmware/app/src/: base64.c config_store.c event_log.c keypad_input.c lock_auth.c lock_controller.c onenet_token.c periodic_credential.c pin_credential.c remote_command.c sha1.c totp.c visitor_credential.c
    firmware/app/include/: base64.h config_store.h event_log.h keypad_input.h lock_auth.h lock_controller.h onenet_token.h periodic_credential.h pin_credential.h remote_command.h sha1.h totp.h visitor_credential.h
  group PLATFORM
    firmware/stm32/src/: board_port.c freertos_hooks.c main.c smart_lock_app.c stm32f10x_it.c
    firmware/stm32/include/: board_port.h FreeRTOSConfig.h smart_lock_app.h smart_lock_board_config.h smart_lock_pinmap.h
  group FreeRTOS
    firmware/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    firmware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    firmware/FreeRTOS/portable/MemMang/: heap_4.c
    firmware/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group USER
    firmware/USER/: app_wifi.c app_alarm.h app_auth.h app_common.h app_link.h app_lock.h app_log.h app_power.h app_ui.h app_wifi.h stm32f10x_conf.h stm32f10x_it.h
  group SYSTEM
    firmware/SYSTEM/: delay.c sys.c usart.c delay.h sys.h usart.h
  group HARDWARE
    firmware/HARDWARE/: as608.c buzzer.c ds3231.c esp8266.c i2c_soft.c mfrc522.c oled.c rgb_led.c servo.c w25q64.c as608.h buzzer.h ds3231.h esp8266.h i2c_soft.h key_4x4.h mfrc522.h oled.h oledfont.h oledfont_cn.h rgb_led.h sensor.h servo.h w25q64.h
  group MIDDLEWARE
    firmware/MIDDLEWARE/: cJSON.c cJSON.h MqttKit.c MqttKit.h
  group StdPeriph
    D:/Keil_v5/Packs/Keil/STM32F1xx_DFP/2.3.0/Device/Source/: system_stm32f10x.c
    D:/Keil_v5/Packs/Keil/STM32F1xx_DFP/2.3.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_iwdg.c
